Commit message: test

File: test/bumpybot/robot.urdf (robot description, URDF)
Before this commit: robot bumpybot, 2 links, 1 joints
Links:
- link pointer: mass 0.0000001 -> 0.00000001
